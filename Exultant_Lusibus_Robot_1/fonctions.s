		AREA    |.text|, CODE, READONLY
		ENTRY
		
		IMPORT	MOTEUR_INIT_DROITE
		IMPORT	MOTEUR_INIT_GAUCHE
		IMPORT	MOTEUR_INIT_RAPIDE
		IMPORT	MOTEUR_DROIT_ON
		IMPORT  MOTEUR_DROIT_OFF
		IMPORT  MOTEUR_DROIT_AVANT
		IMPORT  MOTEUR_DROIT_ARRIERE
		IMPORT  MOTEUR_DROIT_INVERSE
		IMPORT	MOTEUR_GAUCHE_ON
		IMPORT  MOTEUR_GAUCHE_OFF
		IMPORT  MOTEUR_GAUCHE_AVANT
		IMPORT  MOTEUR_GAUCHE_ARRIERE
		IMPORT  MOTEUR_GAUCHE_INVERSE
			
		
		IMPORT WAIT_MESURE
		IMPORT WAIT_BLANCHE
		IMPORT WAIT_NOIRE
		IMPORT WAIT_CROCHE
		IMPORT WAIT_TRIOLET
		IMPORT WAIT_DCROCHE
		IMPORT WAIT_TCROCHE	
		IMPORT FIN
			
		EXPORT PARTIE2
		
			
PARTIE2 ldr r12, =0x03

move128
		BL MOTEUR_INIT_GAUCHE
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_BLANCHE

		BL MOTEUR_INIT_GAUCHE
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_BLANCHE

		BL MOTEUR_INIT_DROITE
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_BLANCHE
		
		BL MOTEUR_INIT_DROITE
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_BLANCHE
		
		subs r12,#1
		bne move128
		
		
		BL MOTEUR_INIT_GAUCHE
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_BLANCHE

		BL MOTEUR_INIT_GAUCHE
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_BLANCHE

		
		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_OFF
		BL WAIT_MESURE

		BL WAIT_TRIOLET
		
		
		
		BL MOTEUR_INIT_RAPIDE
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_ON
		
				ldr r12,=0x03
move1
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_NOIRE

		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_NOIRE
		
		subs r12,#1
		bne move1
		
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_NOIRE

		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_OFF
		BL WAIT_NOIRE
		
		BL WAIT_MESURE
		BL WAIT_MESURE
		
		; MESURE 7
		
		
		
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_ON
		
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_NOIRE
		
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_AVANT
		BL WAIT_NOIRE
		
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_NOIRE

		
		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_OFF
		BL WAIT_NOIRE
		BL WAIT_MESURE
		
		
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_ARRIERE
		
		
		ldr r12,=0x06
move2
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_OFF
		BL WAIT_TRIOLET
		
		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_ON
		BL WAIT_TRIOLET
		
		subs r12,#1
		bne move2
		
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_ON

		BL MOTEUR_DROIT_AVANT
		BL MOTEUR_GAUCHE_AVANT
		BL WAIT_BLANCHE

		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_OFF
		BL WAIT_BLANCHE
		
		BL WAIT_BLANCHE
		BL WAIT_CROCHE
		
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_ON
		BL MOTEUR_GAUCHE_ARRIERE
		BL MOTEUR_DROIT_AVANT
		BL WAIT_CROCHE
		
		BL MOTEUR_GAUCHE_ON
		BL MOTEUR_DROIT_ON
		BL MOTEUR_GAUCHE_AVANT
		BL MOTEUR_DROIT_ARRIERE
		BL WAIT_CROCHE
		
		
		
		
		BL MOTEUR_GAUCHE_OFF
		BL MOTEUR_DROIT_OFF
		
		BL FIN
		BX LR


		
END

	
